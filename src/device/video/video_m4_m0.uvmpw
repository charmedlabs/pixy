<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>WorkSpace</WorkspaceName>

  <project>
    <PathAndName>.\video.uvproj</PathAndName>
    <NodeIsActive>1</NodeIsActive>
  </project>

  <project>
    <PathAndName>.\m0.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>..\libpixy\libpixy_m0.uvproj</PathAndName>
  </project>

  <project>
    <PathAndName>..\libpixy\libpixy_m4.uvproj</PathAndName>
  </project>

</ProjectWorkspace>
