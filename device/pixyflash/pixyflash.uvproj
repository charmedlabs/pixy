# Keil uVision project pixyflash.uvproj, settings and files
target pixyflash (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: pixyflash +hex
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4
  c include: ., ..\libpixy
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10080000 size 0x12000
  group source
    ./: main.cpp flash.cpp
  group libs
    ../libpixy/: libpixy_m4.lib
