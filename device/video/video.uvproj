# Keil uVision project video.uvproj, settings and files
target Flash (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: video +hex
  c flags: Optim=1
  c define: CORE_M4 IPC_MASTER DEBUG
  c include: ., ..\libpixy
  asm define: NO_CRP
  memory RVCT4: ROM 0x10080000 size 0x12000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\video.sct
  group Source Code
    ./: main_m4.cpp conncomp.cpp cblob.cpp param.cpp
    ../libpixy/: libpixy_m4.lib
target RAM (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: video +hex
  c flags: Optim=1
  c define: CORE_M4 IPC_MASTER DEBUG
  c include: ., ..\libpixy
  asm define: NO_CRP
  memory RVCT4: ROM 0x10080000 size 0x12000
  memory RVCT9: RAM 0x20000000 size 0x8000
