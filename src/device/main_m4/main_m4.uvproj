# Keil uVision project main_m4.uvproj, settings and files
target Flash (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: pixy_firmware +hex
  c flags: Optim=1
  c define: CORE_M4 IPC_MASTER PIXY
  c include: ., ..\libpixy_m4\inc, ..\..\common\inc, ..\common\inc, inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\spifi.sct
  group Source Code
    ./src/: analogdig.cpp button.cpp conncomp.cpp exec.cpp i2c.cpp progblobs.cpp progchase.cpp progpt.cpp progvideo.cpp serial.cpp spi.cpp uart.cpp main_m4.cpp
    ../libpixy_m4/: libpixy_m4.lib
    ../../common/src/: blob.cpp blobs.cpp calc.cpp colorlut.cpp qqueue.cpp
target RAM (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: main_m4 +hex
  c flags: Optim=1
  c define: CORE_M4 IPC_MASTER PIXY
  c include: ., ..\libpixy_m4\inc, ..\..\common\inc, ..\common\inc, inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\ram.sct
