# Keil uVision project libpixy_m4.uvproj, settings and files
target libpixy_m4 (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: libpixy_m4 (library)
  c flags: Optim=1 OneElfS=1
  c define: CORE_M4 IPC_MASTER PIXY KEIL
  c include: ., ..\..\common\inc, ..\common\inc, inc
  asm define: NO_CRP
  group Source Code
    ./src/: camera.cpp chirpm0.cpp chirpusb.cpp flash.cpp fpu_init.c led.cpp misc.cpp param.cpp pixy_init.cpp platform_config.c power.cpp rcservo.cpp sccb.cpp smlink.cpp startup_LPC43xx_m4.s usbcore.c usbdesc.c usbhw.c usblink.cpp usbuser.c
    ../common/src/: debug_frmwrk.c ipc_mbx.c lpc43xx_adc.c lpc43xx_cgu.c lpc43xx_i2c.c lpc43xx_scu.c lpc43xx_ssp.c lpc43xx_uart.c system_LPC43xx.c
    ../../common/src/: calc.cpp chirp.cpp
  group libs
    ./: spifi_drv_M4.lib
