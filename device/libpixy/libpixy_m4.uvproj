# Keil uVision project libpixy_m4.uvproj, settings and files
target libpixy_m4 (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: libpixy_m4 (library)
  c flags: Optim=1 OneElfS=1
  c define: CORE_M4 IPC_MASTER
  c include: .
  asm define: NO_CRP
  group Source Code
    ./: debug_frmwrk.c fpu_init.c lpc43xx_adc.c lpc43xx_cgu.c lpc43xx_scu.c lpc43xx_uart.c platform_config.c system_LPC43xx.c usbcore.c usbdesc.c usbhw.c usbuser.c chirp.cpp sccb.cpp usblink.cpp ipc_mbx.c pixy_init.cpp startup_LPC43xx_m4.s smlink.cpp camera.cpp chirpm0.cpp led.cpp rcservo.cpp misc.cpp power.cpp spi.cpp lpc43xx_ssp.c param.cpp flash.cpp
    ../libpixy/: chirpusb.cpp
  group libs
    ./: spifi_drv_M4.lib
